# Keil uVision project bf5823a.uvprojx, settings and files
target bf5823a (MCS-51)
  device: BF5823AM48 BYD_MCU
  cpu: IRAM(0-0xFF) IROM(0-0xFBFF) XRAM(0-0xFFF)CLOCK(12000000)
  output: DS08_HEX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\Library\byd_standard_peripheral\include;.\byd_api\byd_key\include;.\byd_api\byd_mifare\include;.\byd_tool_comm;.\byd_rfid;.\mmi_inc
  link misc: REMOVEUNUSED
  group StartUp
    ./source/: STARTUP.A51
  group Source
    ./source/: byd_idle.c byd_ctk.c byd_adc.c byd_sm4.c byd_led.c byd_spi_flash.c byd_eeprom.c mcu02_isr.c delay.c main.c dqiot_drv.c dqiot_drv_audio.c dqiot_drv_fp.c dqiot_fp_sy.c dqiot_drv_ldo.c dqiot_drv_led.c dqiot_drv_motor.c dqiot_drv_reset.c dqiot_drv_rfid.c dqiot_drv_touch.c dqiot_drv_wifi.c iic_master.c
  group byd_key
    ./byd_api/: byd_key_v1.0.3.LIB
  group byd_rfid
    ./byd_rfid/: iso14443.c byd_mifare.c
  group byd_mifare
    ./byd_api/: byd_mifare_v1.0.1.LIB
  group byd_peripherals
    ./Library/byd_standard_peripheral/source/: mcu02_system.c mcu02_csd.c mcu02_wdt.c mcu02_clock.c mcu02_gpio.c mcu02_iic.c mcu02_timer.c mcu02_lvdt.c mcu02_spi.c mcu02_uart.c mcu02_rfid.c mcu02_pwm.c mcu02_exint.c mcu02_adc.c mcu02_led.c mcu02_flash.c mcu02_sm4.c mcu02_lowpower.c mcu02_eeprom.c
  group byd_tool_comm
    ./byd_tool_comm/: byd_tracemode.c
  group mmi
    ./mmi_src/: mmi_queue.c mmi_key.c mmi_ms.c mmi_audio.c mmi_sys.c mmi_fps.c mmi_com.c mmi_bsp.c mmi_rfid.c mmi_rst.c mmi_fs.c mmi_motor.c mmi_fm.c mmi_wifi.c dq_otp.c mmi_decode.c dq_sdk_main.c mmi_time.c
